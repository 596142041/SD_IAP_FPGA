# Keil uVision project sd_iap_fpga.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sd_iap_fpga
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\include;.\fatfs;.\fwlib\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start_up
    ./: startup_stm32f40_41xxx.s
  group main
    ./main/: main.c
  group driver
    ./driver/: key.c led.c stm32f4xx_it.c stm324xg_eval.c stm324xg_eval_sdio_sd.c system_stm32f4xx.c
  group usb
    ./usb_mass/: STM324xG-EVAL_HS.lib usb_mass.c
  group fatfs
    ./fatfs/: diskio.c ff.c
  group fwlib
    ./fwlib/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_dma.c
software components: CMSIS:CORE 4.3.0
